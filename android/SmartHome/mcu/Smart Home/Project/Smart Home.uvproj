# Keil uVision project Smart Home.uvproj, settings and files
target Smart Home (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Smart Home +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE;..\USER
  group USER
    ./: STARTUP.A51
    ../USER/: main.c
  group HARDWARE
    ../HARDWARE/: ADDA.c Alert.c DHT11.c DS1302.c EEPROM.c JDQ.c LCD1602.c LED.c SerialComm.C
